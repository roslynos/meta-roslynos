ALTERNATIVE:${PN} += "pwsh"
ALTERNATIVE_PRIORITY[pwsh] = "50"
ALTERNATIVE_LINK_NAME[pwsh] = "${base_bindir}/pwsh"