FILESEXTRAPATHS:prepend := "${THISDIR}/raspberrypi:"

# SRC_URI:append = " \
#     file://gpio-sysfs.cfg \
# "